# Keil uVision project Temp03.uvprojx, settings and files
target Temp03 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp03 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, HSE_VALUE = 8000000
  c include: .\Inc;..\..\..\..\001libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\001libraries\STM32F4xx_StdPeriph_Driver;..\..\..\..\001libraries\stm32f4_discovery;..\..\..\..\001libraries\stm32f4_discovery_shu\inc;..\..\..\..\001libraries\stm32f4_discovery_shu;..\..\..\..\001libraries\TM_STM32F4XX;.\RTE\Device\STM32F407VGTx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Src/: main.c main_menu.h
    ./: Timer.c
  group Include
    ./Inc/: main.h osObjects.h definitions.h lcd_elements.h
  group Stm32f4_StdPeriph_Driver
    ../../../../001libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_usart.c
  group Stm32f4_Discovery
    ../../../../001libraries/stm32f4_discovery/: stm32f4_discovery_lcd.c
  group Stm32f4_Discovery_SHU
    ../../../../001libraries/stm32f4_discovery_shu/src/: adc.c
  group TM_Stm32f4
    ../../../../001libraries/TM_STM32F4XX/: tm_stm32f4_ds1307.c tm_stm32f4_gpio.c tm_stm32f4_i2c.c
  group Documentation
    ./Doc/: Doc_Pins.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 2.4.0
